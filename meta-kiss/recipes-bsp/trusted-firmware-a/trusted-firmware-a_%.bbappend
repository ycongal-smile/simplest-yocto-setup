COMPATIBLE_MACHINE:stompduck = "^stompduck$"
COMPATIBLE_MACHINE:stompduck2 = "^stompduck2$"

# trusted-firmware-a can depend on "u-boot", we have "u-boot-kiss"
DEPENDS += "virtual/bootloader"
